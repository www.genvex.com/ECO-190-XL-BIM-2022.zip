Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2022-02-03T11:31:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 24.0.16800.0000 - Exporter 20.0.0.364 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 03 11:31:00 2022 * Host: NINB1532 * Database: C:\Users\3113thmo\AppData\Local\Temp\5169a31f-b503-4158-95a4-e4c5af68bd48\4298e8ae-e8b9-43a6-9896-48c49ba8dbef\ifc * Database version: 5507 * Database creation date: Thu Feb 03 11:30:53 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 03 11:30:53 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 03 11:30:53 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:205336
In: Level 1
Type - Material: 162_162_162, 255_0_0, 64_64_64
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connector_1_Diameter: 0 mm; Connector_2_Diameter: 0 mm; Connector_3_Diameter: 0 mm; Connector_4_Diameter: 0 mm; Connector_5_Diameter: 0 mm
Type - Identity Data - Description: Right version; Manufacturer: Genvex; Model: ECO 190; Type Name: Standard; URL: https://www.genvex.com/produkter/ventilation/eco-190-ventilationsanlaeg
Type - Other - Category: Generic Models; Family Name: Family1
Type - Pset_BuildingElementProxyCommon - Reference: Standard
Type - Pset_ManufacturerTypeInformation - Manufacturer: Genvex
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Standard
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 1.40767 m2; Volume: 0.193202 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection
2 x Port_205336 | SOURCE
3 x Port_205336 | SINK
